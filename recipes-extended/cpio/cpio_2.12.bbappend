FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Wrong-CRC-with-ASCII-CRC-for-large-files.patch"

