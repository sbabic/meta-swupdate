SRCBRANCH = "2026.05-y"
SRCREV = "6afadb8c03c983d4faa5b14dc259caaceea7db1b"
require swupdate.inc
