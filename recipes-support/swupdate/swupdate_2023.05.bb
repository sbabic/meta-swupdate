require swupdate.inc

SRCREV = "954e8c0b0f24fdd8f17ae7d382ff96622b95111a"
