require swupdate-legacy.inc
require swupdate_tools.inc

SRCREV = "e83730c4ec30134cdf56a2fd1d62a3767ade8133"
