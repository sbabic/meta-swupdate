require swupdate.inc
require swupdate_tools.inc

SRCREV = "5e381a6ad965f2fba51c19306f8dd683140ffb12"
