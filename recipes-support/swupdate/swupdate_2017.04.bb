require swupdate.inc

SRCREV = "d344ec10b71293d2aaf96816266d4e6ed1d3bf6a"
