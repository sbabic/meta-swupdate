require swupdate.inc

SRCREV = "2042e6dc0f5466bd428f4db18eaff638203150ad"
