require swupdate.inc

SRCREV = "d542b7fa7c8b7ddb75e7cb3335f5a2590df2edab"
