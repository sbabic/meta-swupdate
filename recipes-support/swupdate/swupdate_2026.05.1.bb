SRCBRANCH = "master"
SRCREV = "9000ecb52677da7d9676a61b729bab57dba99674"
require swupdate.inc
