require swupdate.inc

SRCREV = "9763342203e32d58cbfed36550b3986b5cf0e52e"
