SRCBRANCH = "master"
SRCREV = "3f7915fb64b4be9d7280e3167219a08348c128f2"
require swupdate.inc
