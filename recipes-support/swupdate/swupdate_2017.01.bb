require swupdate.inc

SRCREV = "1ab938fa4bd2a75b6f44f565ac877f3c5b428521"
