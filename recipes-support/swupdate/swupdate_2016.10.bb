require swupdate.inc

SRCREV = "edd6559728d2e234ebdc03ba1d5444449ae2b92b"
