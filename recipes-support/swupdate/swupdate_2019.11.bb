require swupdate.inc

SRCREV = "5de3bc30a203ee218f9ebbe256b42e26cf06c74f"

# Building out of tree is broken in this version
B = "${S}"
