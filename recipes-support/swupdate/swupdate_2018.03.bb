require swupdate-legacy.inc
require swupdate_tools.inc

SRCREV = "25a35039bc67905b636d871272a682e766a33165"
