require swupdate.inc

SRCREV = "43530f0c9068a1574ef27837f4a29826089057e4"
