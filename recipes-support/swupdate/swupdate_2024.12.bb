require swupdate.inc

SRCREV = "33c5688590e811c9d54101accc6ea368ea5f0f50"
