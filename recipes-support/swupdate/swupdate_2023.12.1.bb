require swupdate.inc

SRCREV = "66952eff1a30701686723ff2fab0576b389620db"
