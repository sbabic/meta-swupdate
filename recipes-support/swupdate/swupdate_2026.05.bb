SRCBRANCH = "master"
SRCREV = "602edf8e57f940791034096c9e24206097b4b7a6"
require swupdate.inc
