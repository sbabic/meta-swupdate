SRCBRANCH = "master"
SRCREV = "498de8f1c086fae1eeeb64b045d0f861575b1e66"
require swupdate.inc
