require swupdate-legacy.inc
require swupdate_tools.inc

SRCREV = "c0fec16b3fc82b0db12d8ac58be7055ed1b8d439"
