require swupdate.inc

SRCREV = "3a333f4b4b1cec5e3cb1f2e3da41ad82735d0242"
