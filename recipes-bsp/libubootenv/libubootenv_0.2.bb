require libubootenv.inc
SRCREV = "bf6ff631c0e38cede67268ceb8bf1383b5f8848e"
