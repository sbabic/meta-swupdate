require libubootenv.inc
SRCREV = "92949816720d7af2ac722016e7a5b9a85ff141bc"
PV_append = "+git${SRCPV}"

DEFAULT_PREFERENCE = "-1"
