RDEPENDS:${PN} += "\
    lua-staticdev \
    mtd-utils-staticdev \
"
